# Keil uVision project M451_Six-axis_Sensor_MPU6050_Driver.uvproj, settings and files
target M451_Six-axis_Sensor_MPU6050_Driver (ARM-ADS)
  device: Cortex-M4 FPU ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M4") ESEL ELITTLE FPU2
  output: MPU6050 +hex
  AfterMake: fromelf --bin ".\output\@L.axf" --output ".\output\@L.bin"
  AfterMake: fromelf --text -c ".\output\@L.axf" --output ".\output\@L.txt"
  c flags: v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\..\..\..\Library\Device\Nuvoton\M451Series\Include;..\..\..\..\Library\CMSIS\Include;..\..\..\..\Library\StdDriver\inc;.\..\eMPL;.\..\
  asm include: .\eMPL
  library: MicroLIB
  link misc: --map --first='startup_M451series.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/M451Series/Source/: system_M451Series.c startup_M451Series.s
  group User
    ./../: main.c Common.c
  group Library
    ../../../../Library/StdDriver/src/: retarget.c clk.c sys.c uart.c i2c.c gpio.c
  group MPU6050
    ./../: SmartMI2C.c MPU6050.c
    ./../eMPL/: inv_mpu.c inv_mpu_dmp_motion_driver.c
