# Keil uVision project M480_WiFi_TCPServer.uvproj, settings and files
target M480_WiFi_TCPServer (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: M487JIDAE Nuvoton
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0-0x7FFFF) CLOCK(84000000) CPUTYPE("Cortex-M4") FPU2
  output: M480_WiFi_TCPServer +hex
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=3 uC99=1 v6Lang=1 v6LangP=1
  c include: ..\..\..\..\Library\StdDriver\inc;..\..\..\..\Library\Device\Nuvoton\M480\Include;..\..\..\..\ThirdParty\FreeRTOS\Source\include;..\..\..\..\ThirdParty\FreeRTOS\Demo\COMMON\include;..\..\..\..\ThirdParty\FreeRTOS\SOURCE\portable\RVDS\ARM_CM4F;..\..\..\..\Library\CMSIS\Include;..\;..\..\..\..\ThirdParty\ESP_AT_Lib\src\include;..\HAL
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group System
    ../../../../Library/Device/Nuvoton/M480/Source/: system_M480.c
    ../../../../Library/Device/Nuvoton/M480/Source/ARM/: startup_M480.s
  group Demo
    ../: main.c NetworkIF_ESP8266.c NetconnServer.c
  group FreeRTOS
    ../../../../ThirdParty/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
    ../../../../ThirdParty/FreeRTOS/Source/: list.c queue.c tasks.c timers.c
    ../../../../ThirdParty/FreeRTOS/Source/portable/MemMang/: heap_2.c
  group Driver
    ../../../../Library/StdDriver/src/: retarget.c sys.c uart.c clk.c pdma.c gpio.c
  group ESP_AT
    ../../../../ThirdParty/ESP_AT_Lib/src/api/: esp_netconn.c
    ../../../../ThirdParty/ESP_AT_Lib/src/esp/: esp_ap.c esp_buff.c esp.c esp_cli.c esp_conn.c esp_debug.c esp_dhcp.c esp_dns.c esp_evt.c esp_hostname.c esp_input.c esp_int.c esp_mdns.c esp_mem.c esp_parser.c esp_pbuf.c esp_ping.c esp_sntp.c esp_sta.c esp_threads.c esp_timeout.c esp_unicode.c esp_utils.c esp_wps.c
    ../../../../ThirdParty/ESP_AT_Lib/src/system/: esp_ll_m48x.c esp_sys_freertos_os.c
    ../../../../ThirdParty/ESP_AT_Lib/src/cli/: cli.c
  group HAL
    ../HAL/: dma.c M48x_UART.c nu_modutil.c M48x_ISR.c
